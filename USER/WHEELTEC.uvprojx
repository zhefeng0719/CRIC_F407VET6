# Keil uVision project WHEELTEC.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: WHEELTEC +hex
  AfterMake: fromelf --bin --output=..\wheeltec.bin ..\OBJ\WHEELTEC.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\BALANCE;..\HARDWARE;..\HARDWARE\MPU6050;..\AutoRecharge;..\HARDWARE\USB\STM32_USB_HOST_Library\Core\inc;..\HARDWARE\USB\STM32_USB_HOST_Library\Class\HID\inc;..\HARDWARE\USB\STM32_USB_OTG_Driver\inc;..\HARDWARE\USB\USB_APP\Inc;..\HARDWARE\ICM20948
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Updatelog
    ../: 更新记录.txt
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/: adc.c can.c encoder.c key.c LED.C motor.c oled.c pstwo.c timer.c usartx.c I2C.c
    ../AutoRecharge/: AutoRecharge.c
    ../HARDWARE/ICM20948/: ICM20948.c
    ../HARDWARE/MPU6050/: MPU6050.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_pwr.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Balance
    ../BALANCE/: system.c balance.c robot_select_init.c show.c imu_task.c
  group USB_OTG
    ../HARDWARE/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../HARDWARE/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../HARDWARE/USB/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c
    ../HARDWARE/USB/USB_APP/: usbh_hid_joy.c
  group USB_APP
    ../HARDWARE/USB/USB_APP/: usb_bsp.c usbh_usr.c
